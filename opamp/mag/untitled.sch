v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pmos67.sym} -50 -120 0 1 {name=x1}
C {pmoscs.sym} -540 -130 0 0 {name=x2}
C {nmos89.sym} -40 30 0 1 {name=x3}
C {nmos34.sym} -530 20 0 0 {name=x4}
C {devices/lab_pin.sym} -200 -150 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -390 -160 0 1 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -380 30 0 1 {name=p3 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -190 50 0 0 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -390 -140 0 1 {name=p5 sig_type=std_logic lab=xxx}
C {devices/lab_pin.sym} -390 -120 0 1 {name=p6 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} -390 -100 0 1 {name=p7 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} -380 -10 0 1 {name=p8 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} -380 10 0 1 {name=p9 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} -380 50 0 1 {name=p10 sig_type=std_logic lab=xxx}
C {devices/lab_pin.sym} -190 10 0 0 {name=p11 sig_type=std_logic lab=xxx}
C {devices/lab_pin.sym} -190 30 0 0 {name=p12 sig_type=std_logic lab=net6}
C {devices/lab_pin.sym} -200 -110 0 0 {name=p13 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} -200 -130 0 0 {name=p14 sig_type=std_logic lab=xxx}
C {devices/lab_pin.sym} -200 -90 0 0 {name=p15 sig_type=std_logic lab=xxx}
